# Keil uVision project 实验十五    DS1302日历时钟实验.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 实验十五    DS1302日历时钟实验 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: AT89S52.H DS1302时钟芯片实验2.C
